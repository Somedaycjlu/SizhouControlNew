# Keil uVision project SizhouControl.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: SizhouControl
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\YUANZILIB\delay;..\YUANZILIB\sys;..\YUANZILIB\usart;..\HARDWARE;..\HARDWARE\OLED;..\HARDWARE\MPU6050;..\HARDWARE\TIM_PWM;..\HARDWARE\TIM_INT;..\SOFTWARE;..\SOFTWARE\SIZHOU_STARTUP;..\SOFTWARE\SIZHOU_CONTROL;..\SOFTWARE\DATA_DEAL;..\HARDWARE\6050DMP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group SYSTEM
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TIM_PWM/: pwm.c
    ../HARDWARE/TIM_INT/: tim_init.c
    ../HARDWARE/6050DMP/: anbt_dmp_driver.c anbt_dmp_mpu6050.c anbt_i2c.c
  group SOFTWARE
    ../SOFTWARE/SIZHOU_STARTUP/: sizhou_startup.c
    ../SOFTWARE/SIZHOU_CONTROL/: sizhou_control.c
    ../SOFTWARE/DATA_DEAL/: data_deal.c
  group YUANZILib
    ../YUANZILIB/delay/: delay.c
    ../YUANZILIB/sys/: sys.c
    ../YUANZILIB/usart/: usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
